<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32WB55CGU6_Dev_board.ewp</path>
  </project>
  <batchBuild />
</workspace>

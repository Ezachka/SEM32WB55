# IAR project STM32WB55CGU6_Dev_board.ewp, settings and files
configuration STM32WB55CGU6_Dev_board (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55CG ST STM32WB55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../USB_Device/App; ../USB_Device/Target; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Utilities/lpm/tiny_lpm; ../Middlewares/ST/STM32_WPAN; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../Middlewares/ST/STM32_WPAN/utilities; ../Middlewares/ST/STM32_WPAN/ble/core; ../Middlewares/ST/STM32_WPAN/ble/core/auto; ../Middlewares/ST/STM32_WPAN/ble/core/template; ../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Middlewares/ST/STM32_WPAN/ble; ../Drivers/CMSIS/Include; ../Utilities/sequencer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc; ../STM32_WPAN/App; ../USB_Device/App; ../USB_Device/Target; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Utilities/lpm/tiny_lpm; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/RTOS2/Include; ../Middlewares/ST/STM32_WPAN; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../Middlewares/ST/STM32_WPAN/utilities; ../Middlewares/ST/STM32_WPAN/ble/core; ../Middlewares/ST/STM32_WPAN/ble/core/auto; ../Middlewares/ST/STM32_WPAN/ble/core/template; ../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Middlewares/ST/STM32_WPAN/ble; ../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: STM32WB55CGU6_Dev_board.hex
  ILINK.IlinkOutputFile: STM32WB55CGU6_Dev_board.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_debug.c app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_hal_timebase_tim.c stm32wbxx_it.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c custom_app.c custom_stm.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_rcc.c stm32wbxx_ll_usb.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_events.c ble_gap_aci.c ble_gatt_aci.c ble_gen_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Services
    ../Core/Src/: BLE_services_custom.c
    ../Core/Inc/: BLE_services_custom.h Board_conf.h
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
